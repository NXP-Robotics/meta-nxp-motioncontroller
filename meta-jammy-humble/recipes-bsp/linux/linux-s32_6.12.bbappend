# Copyright 2026 NXP

DEBUG_PREFIX_MAP:remove = "-fcanon-prefix-map"